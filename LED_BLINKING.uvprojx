# Keil uVision project LED_BLINKING.uvprojx, settings and files
target Target 1 (6130001::V6.13.1::.\ARMCLANG)
  device: TM4C123GH6PM Texas Instruments
  pack: Keil.TM4C_DFP.1.1.0
  cpu: IRAM(0x20000000,0x008000) IROM(0x00000000,0x040000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: LED_BLINKING
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  c include: .\App;.\Common;.\Config;.\Inc
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group App
    ./App/: App.c App.h Led.c Led.h Led_Cfg.h main.c
  group Mcal
    ./MCAL/: Dio.c Gptm.c IntCtrl.c Port.c
  group Common
    ./Common/: Common_Macros.h Compiler.h Platform_Types.h Std_Types.h tm4c123gh6pm_registers.h
  group Config
    ./Config/: Dio_Cfg.h Dio_PBcfg.c Gpt_Lcfg.c Gptm_Cfg.h IntCtrl_Cfg.h IntCtrl_Lcfg.c Port_Cfg.h Port_Lcfg.c
  group Inc
    ./Inc/: Dio.h Dio_Regs.h Gpt_Regs.h Gptm.h IntCtrl.h IntCtrl_Regs.h Port.h Port_Regs.h
software components: CMSIS:CORE 5.6.0, Device:Startup 1.0.1
